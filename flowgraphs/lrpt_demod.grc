<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>satnogs_lrpt_demod</value></param>
<param><key>author</key><value>Mark Jessop (vk5qi@rfhead.net)</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>A METEOR LRPT demodulation block</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>LRPT Demodulator</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_gain</value></param>
<param><key>comment</key><value>Decimation factor
for the RX after the
SDR received samples</value></param>
<param><key>value</key><value>satnogs.fm_demod_settings[rx_sdr_device]['audio_gain']</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bitstream_name</value></param>
<param><key>value</key><value>"/tmp/" + os.path.basename(decoded_data_file_path) + "_" + datetime.utcnow().strftime("%Y-%m-%dT%H-%M-%S") + ".s"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>clock_alpha</value></param>
<param><key>value</key><value>1e-3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimation_rx</value></param>
<param><key>comment</key><value>Decimation factor
for the RX after the
SDR received samples</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>satnogs.fm_demod_settings[rx_sdr_device]['decimation_rx']</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>deviation</value></param>
<param><key>value</key><value>17000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filter_rate</value></param>
<param><key>value</key><value>250000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pll_alpha</value></param>
<param><key>value</key><value>15e-3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>quadrature_rate</value></param>
<param><key>value</key><value>156250</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_rx</value></param>
<param><key>comment</key><value>SDR device 
TX sampling rate</value></param>
<param><key>value</key><value>satnogs.hw_rx_settings[rx_sdr_device]['samp_rate']</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>(quadrature_rate*1.0)/(symb_rate*1.0)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symb_rate</value></param>
<param><key>value</key><value>72000</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>taps</value></param>
<param><key>cutoff_freq</key><value>100e3</value></param>
<param><key>gain</key><value>12.0</value></param>
<param><key>samp_rate</key><value>samp_rate_rx</value></param>
<param><key>width</key><value>60000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>xlate_filter_taps</value></param>
<param><key>value</key><value>firdes.low_pass(1, samp_rate_rx, 125000, 25000, firdes.WIN_HAMMING, 6.76)</value></param>
</block>
<block>
<key>analog_agc_xx</key>
<param><key>id</key><value>analog_agc_xx_0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>4000</value></param>
<param><key>rate</key><value>1000e-4</value></param>
<param><key>reference</key><value>0.5</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_rail_ff</key>
<param><key>id</key><value>analog_rail_ff_0</value></param>
<param><key>hi</key><value>1</value></param>
<param><key>lo</key><value>-1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>antenna</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>satnogs.not_set_antenna</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bb_gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>satnogs.not_set_rx_bb_gain</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>blks2_rational_resampler_xxx_1</value></param>
<param><key>decim</key><value>16</value></param>
<param><key>interp</key><value>10</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>bitstream_name</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_float_to_char</key>
<param><key>id</key><value>blocks_float_to_char_0</value></param>
<param><key>scale</key><value>127</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decoded_data_file_path</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>/tmp/.satnogs/data/data</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dev_args</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>satnogs.not_set_dev_args</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>gain_mu</key><value>clock_alpha</value></param>
<param><key>gain_omega</key><value>clock_alpha**2/4.0</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>omega</key><value>sps</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_constellation_soft_decoder_cf</key>
<param><key>id</key><value>digital_constellation_soft_decoder_cf_1</value></param>
<param><key>constellation</key><value>digital.constellation_calcdist(([-1-1j, -1+1j, 1+1j, 1-1j]), ([0, 1, 3, 2]), 4, 1).base()</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>w</key><value>pll_alpha</value></param>
<param><key>order</key><value>4</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>doppler_correction_per_sec</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>enable_iq_dump</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>file_path</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>test.wav</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>lo_offset</value></param>
<param><key>decim</key><value>int(samp_rate_rx/filter_rate)</value></param>
<param><key>samp_rate</key><value>samp_rate_rx</value></param>
<param><key>taps</key><value>xlate_filter_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>if_gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>satnogs.not_set_rx_if_gain</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from datetime import datetime</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>import os.path</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>iq_file_path</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>/tmp/iq.dat</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lo_offset</value></param>
<param><key>comment</key><value>To avoid the SDR carrier at the DC
we shift the LO a little further</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>100e3</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>ant0</key><value>satnogs.handle_rx_antenna(rx_sdr_device, antenna)</value></param>
<param><key>bb_gain0</key><value>satnogs.handle_rx_bb_gain(rx_sdr_device, bb_gain)</value></param>
<param><key>bw0</key><value>samp_rate_rx</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>corr0</key><value>ppm</value></param>
<param><key>freq0</key><value>rx_freq - lo_offset</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>satnogs.handle_rx_if_gain(rx_sdr_device, if_gain)</value></param>
<param><key>gain0</key><value>satnogs.handle_rx_rf_gain(rx_sdr_device, rf_gain)</value></param>
<param><key>args</key><value>satnogs.handle_rx_dev_args(rx_sdr_device, dev_args)</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate_rx</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ppm</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>satnogs.not_set_rx_rf_gain</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rigctl_port</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4532</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_0</value></param>
<param><key>alpha</key><value>0.6</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>ntaps</key><value>361</value></param>
<param><key>samp_rate</key><value>quadrature_rate</value></param>
<param><key>sym_rate</key><value>symb_rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>100e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_sdr_device</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>rtlsdr</value></param>
</block>
<block>
<key>satnogs_coarse_doppler_correction_cc</key>
<param><key>id</key><value>satnogs_coarse_doppler_correction_cc_0</value></param>
<param><key>sampling_rate</key><value>samp_rate_rx</value></param>
<param><key>target_freq</key><value>rx_freq</value></param>
</block>
<block>
<key>satnogs_tcp_rigctl_msg_source</key>
<param><key>id</key><value>satnogs_tcp_rigctl_msg_source_0</value></param>
<param><key>addr</key><value>"127.0.0.1"</value></param>
<param><key>mtu</key><value>1500</value></param>
<param><key>mode</key><value>False</value></param>
<param><key>port</key><value>rigctl_port</value></param>
<param><key>interval</key><value>1000</value></param>
</block>
<block>
<key>satnogs_waterfall_sink</key>
<param><key>id</key><value>satnogs_waterfall_sink_0</value></param>
<param><key>center_freq</key><value>0.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>filename</key><value>waterfall_file_path</value></param>
<param><key>mode</key><value>1</value></param>
<param><key>pps</key><value>8</value></param>
<param><key>samp_rate</key><value>quadrature_rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>waterfall_file_path</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>/tmp/waterfall.dat</value></param>
</block>
<connection><source_block_id>analog_agc_xx_0</source_block_id><sink_block_id>root_raised_cosine_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_rail_ff_0</source_block_id><sink_block_id>blocks_float_to_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_rational_resampler_xxx_1</source_block_id><sink_block_id>analog_agc_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_rational_resampler_xxx_1</source_block_id><sink_block_id>satnogs_waterfall_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_char_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>digital_constellation_soft_decoder_cf_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_soft_decoder_cf_1</source_block_id><sink_block_id>analog_rail_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>blks2_rational_resampler_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>satnogs_coarse_doppler_correction_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satnogs_coarse_doppler_correction_cc_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satnogs_tcp_rigctl_msg_source_0</source_block_id><sink_block_id>satnogs_coarse_doppler_correction_cc_0</sink_block_id><source_key>freq</source_key><sink_key>freq</sink_key></connection>
</flow_graph>
